# Keil uVision project heiheihei.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: heiheihei +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c car.c car.h motor.c motor.h xunji.c xunji.h chaoshengbo.c chaoshengbo.h bluebee.c bluebee.h
